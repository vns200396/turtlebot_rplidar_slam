# Keil uVision project underROS.uvprojx, settings and files
target base (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: underROS
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User\App;.\User\Comm;.\User\Main;.\User\Motor;.\User\System;.\User\ADXL345;.\User\Led;.\User\Sonar_SRF04;.\User\PID_Beta6
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./User/System/: system.c SysTick.c
  group App
    ./User/App/: usart.c ringbuf.c tim.c mylib.h mylib.c
  group Main
    ./User/Main/: main.c stm32f10x_it.c
  group Led
    ./User/Led/: led.h led.c
  group ADXL345
    ./User/ADXL345/: adxl345.h adxl345.c
  group Sonar_SRF04
    ./User/Sonar_SRF04/: srf04.h srf04.c
  group Motor
    ./User/Motor/: motor.c motor.h pid_controller.c pid_controller.h
  group Comm
    ./User/Comm/: comm.c comm.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
